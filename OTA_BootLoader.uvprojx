# Keil uVision project OTA_BootLoader.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OTA_BootLoader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: __RTE_DEVICE_H
  c include: .\Hardware;.\OTA;.\User;.\RTE;.\RTE\Device\STM32F103C8
  memory RVCT4: ROM 0x8000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c
  group OTA
    ./Hardware/: ota_info.c
    ./OTA/: ota_protocol.c ota_uart.c ota_update.c esp8266_http.c
  group Hardware
    ./Hardware/: usart.c SPI.c W25Q64.c app_jump.c Delay.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:CRC 3.6.0, Device:StdPeriph Drivers:DMA 3.6.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
